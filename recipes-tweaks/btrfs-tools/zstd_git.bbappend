SRC_URI = "git://github.com/facebook/zstd.git;nobranch=1"
